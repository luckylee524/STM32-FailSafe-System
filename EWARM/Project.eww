<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FailSafe_CAN_ECU.ewp</path>
  </project>
  <batchBuild />
</workspace>
